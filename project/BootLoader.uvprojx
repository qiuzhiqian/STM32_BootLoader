# Keil uVision project BootLoader.uvprojx, settings and files
target BootLoader (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BootLoader +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\cmsis;..\lib\inc;..\user;..\user\timer;..\user\usart;..\user\common;..\user\ymodem
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ../user/: main.c stm32f10x_it.c upload.c download.c
    ../user/timer/: timer.c
    ../user/usart/: usart.c
    ../user/common/: common.c
    ../user/ymodem/: ymodem.c
  group lib
    ../lib/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group cmsis
    ../cmsis/: system_stm32f10x.c core_cm3.c
  group startup
    ../startup/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_hd_vl.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
